# Repository sanqing333/Projet_PCB_5A_Chen_Yiyang

## KiCad design Projet_KICAD/Projet_PCBPolytech_git.kicad_pcb

Parts:
C1, C2, C10, C11, C14, C15: 100n; C_0805_2012Metric
C3, C4, C6, C7: 100n; C_0603_1608Metric
C5, C8: 4.7u; C_0805_2012Metric
C9, C12, C13: 1u; C_0805_2012Metric
D1, D2: LED; LED_0805_2012Metric
J1: SWD; PinHeader_1x05_P2.54mm_Vertical
J2: USB_B_Micro; USB_Micro-AB_Molex_47590-0001
J3: Conn_01x05_Socket; PinHeader_1x05_P2.54mm_Vertical
J4: Conn_01x03_Socket; PinSocket_1x03_P2.54mm_Vertical
Q1, Q2: BSS138; SOT-23
R1, R6: 10k; R_0805_2012Metric
R2, R4: 1K; R_0805_2012Metric
R3, R5, R7: 10K; R_0805_2012Metric
R8, R9, R10, R11: 4.7K; R_0805_2012Metric
SW1: SW_Push; SW_Push_1P1T_NO_CK_KSC6xxG
U1: PM004MNIATR; SOP-8_L4.9-W3.9-P1.27-LS6.0-BL; MPN PM004MNIATR; LCSC Part C5444277
U2: STM32F446RETx; LQFP-64_10x10mm_P0.5mm
U3: AP2112K-3.3; SOT-23-5
U4: USBLC6-2SC6; SOT-23-6_Handsoldering
U5: CH340C; SOIC-16_3.9x9.9mm_P1.27mm

Connections:
+3V3: C2.1, C3.1, C4.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C13.1, C14.1, C15.1, J1.1, Q1.1 (G), Q2.1 (G), R2.2, R3.1, R5.1, R8.1, R9.1, U1.8 (VCC), U2.1 (VBAT), U2.13 (VDDA), U2.19 (VDD), U2.32 (VDD), U2.48 (VDD), U2.64 (VDD), U3.5 (VOUT), U5.4 (V3), U5.16 (VCC)
+5V: C12.1, J2.1 (VBUS), J3.2, R10.1, R11.1, U3.1 (VIN), U3.3 (EN), U4.5 (VBUS)
/CH340C UD+: U4.6 (I/O1), U5.5 (UD+)
/CH340C UD-: U4.4 (I/O2), U5.6 (UD-)
/I2C1_SCL: Q1.2 (S), R8.2, U2.58 (PB6)
/I2C1_SDA: Q2.2 (S), R9.2, U2.59 (PB7)
/JTCK-SWCLK: J1.4, U2.49 (PA14)
/JTMS-SWDIO: J1.2, U2.46 (PA13)
/RESET_STM_N: C1.1, J1.5, R5.2, SW1.2, U2.7 (NRST)
/RTC_SCL_5V: J3.4, Q1.3 (D), R10.2
/RTC_SDA_5V: J3.3, Q2.3 (D), R11.2
/RUN_LED: R4.2, U2.8 (PC0)
/SPI1_MISO: U1.2 (SO/SIO[1]), U2.22 (PA6)
/SPI1_MOSI: U1.5 (SI/SO[0]), U2.23 (PA7)
/SPI1_NSS: R3.2, U1.1 (~CE), U2.20 (PA4)
/SPI1_SCK: U1.6 (CLK), U2.21 (PA5)
/UART4_CTS: U2.26 (PB0), U5.14 (~RTS)
/UART4_RTS: U2.50 (PA15), U5.9 (~CTS)
/UART4_RX: J4.1, U2.15 (PA1), U5.2 (TXD)
/UART4_TX: J4.2, U2.14 (PA0), U5.3 (RXD)
/USB_D+: J2.3 (D+), U4.1 (I/O1)
/USB_D-: J2.2 (D-), U4.3 (I/O2)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, D1.1 (K), D2.1 (K), J1.3, J2.5 (GND), J2.SH (Shield), J3.1, J4.3, R1.2, R6.1, R7.2, SW1.1, U1.4 (VSS), U2.12 (VSSA), U2.18 (VSS), U2.31 (VSS), U2.47 (VSS), U2.63 (VSS), U3.2 (GND), U4.2 (GND), U5.1 (GND), U5.15 (R232)
unnamed: D1.2 (A), R2.1
unnamed: D2.2 (A), R4.1
unnamed: R1.1, U1.3 (SIO[2])
unnamed: R6.2, U1.7 (SIO[3])
unnamed: R7.1, U2.60 (BOOT0)
unnamed: C5.1, U2.30 (VCAP_1)

Notes on the sheet:
RTCConnector
双向电平转换_SCL
VDD
VDDA
静电保护装置
crystal
boutton poussoir
VBAT
Protections
usb <-> uart 模块
双向电平转换_SDA
run_led
charger led
USB

Board: 4 copper layers, 48.4 x 46.0 mm, 40 parts (0 on the bottom side), 29 nets.

File Projet_KICAD/production/I2C_Debugger_4L_bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C10, C11, C14, C15, C2",0805,6,100n,
"C12, C13, C9",0805,3,1u,
"C3, C4, C6, C7",0603,4,100n,
"C5, C8",0805,2,4.7u,
"D1, D2",0805,2,LED,
J1,PinHeader_1x05_P2.54mm_Vertical,1,SWD,
J2,USB_Micro-AB_Molex_47590-0001,1,USB_B_Micro,
J3,PinHeader_1x05_P2.54mm_Vertical,1,Conn_01x05_Socket,
J4,PinSocket_1x03_P2.54mm_Vertical,1,Conn_01x03_Socket,
"Q1, Q2",SOT-23,2,BSS138,
"R1, R3, R5, R6, R7",0805,5,10k,
"R10, R11, R8, R9",0805,4,4.7K,
"R2, R4",0805,2,1K,
SW1,SW_Push_1P1T_NO_CK_KSC6xxG,1,SW_Push,
U1,SOP-8_L4.9-W3.9-P1.27-LS6.0-BL,1,PM004MNIATR,C5444277
U2,LQFP-64_10x10mm_P0.5mm,1,STM32F446RETx,
U3,SOT-23-5,1,AP2112K-3.3,
U4,SOT-23-6_Handsoldering,1,USBLC6-2SC6,
U5,SOIC-16_3.9x9.9mm_P1.27mm,1,CH340C,

## KiCad design LED_Practice/LED_Practice.kicad_pcb

Parts:
D1: LED; LED_0805_2012Metric
J1: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
R1: 330R; R_0805_2012Metric

Connections:
+3.3V: J1.1, R1.1
GND: D1.1 (K), J1.2
unnamed: D1.2 (A), R1.2

Board: 4 copper layers, 18.5 x 12.5 mm, 3 parts (0 on the bottom side), 3 nets.
